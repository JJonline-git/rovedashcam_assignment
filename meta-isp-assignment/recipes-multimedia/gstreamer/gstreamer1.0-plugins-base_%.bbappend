# Only the elements we use: appsrc (app plugin, always built). Drops pango/cairo/fonts, theora, vorbis.
PACKAGECONFIG = "${GSTREAMER_ORC}"
